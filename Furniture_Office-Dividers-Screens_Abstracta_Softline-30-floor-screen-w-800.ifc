Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Office-Dividers-Screens_Abstracta_Softline-30-floor-screen-w-800.ifc
Time: 2018-07-23T11:16:47
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Softline 30 floor screen w 800
ePset_BIMobjectScript - Shelves: On; Base: Legs; Size: 800x1360x30; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Softline 30 floor screen w 800; SKU (BO_prodsku): Softline_30_w800; ManufacturName (BO_Manufac): Abstracta; BrandUrl (BO_brandurl): http://abstracta.se/; ProductFamily (BO_prodfam): Acoustic; ProductGroup (BO_prodgroup): Softline; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 8/18/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 800; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/abstracta/product/Softline_30_w800; ProductDataUrl (BO_prodaturl): bimobject.com/abstracta/product/Softline_30_w800; ProductUrl (BO_producturl): https://abstracta.se/product/softline/; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Wood; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Office Dividers & Screens; BimObjectCategoryCode (BO_bocat_code): furniture-office-screens; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): SS-25-25-05; Uniclass20Description (BO_uniclass_2_0_desc): Acoustic Panel Systems; MasterFormat2014Code (BO_masterformat2014_code): 12 50 00; MasterFormat2014Description (BO_masterformat2014_name): Furniture; RegionEurope (BO_europe): SE
